Properties of the parts of a building model (IFC2X3)

# File
Description: IFC 2x3 Building Model
Time: 2021-02-09T15:33:54
Author: Mayow, Feodor
Organization: WSP Europe
Made in: ASIFC - 2.11.0.854

# IfcSite
RefElevation: 0 mm

# IfcProxy (11)
ProxyType: PRODUCT
Name
2 x L1
L1.005
3 x L1.006
L1.004
L1.003
L1.002
2 x L1.001
